<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3166</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>8</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package checked="true" name="STDCHECKS">
            <group checked="true" name="ARR">
              <check checked="true" name="ARR-inv-index-pos"/>
              <check checked="true" name="ARR-inv-index-ptr-pos"/>
              <check checked="true" name="ARR-inv-index-ptr"/>
              <check checked="true" name="ARR-inv-index"/>
              <check checked="true" name="ARR-neg-index"/>
              <check checked="true" name="ARR-uninit-index"/>
            </group>
            <group checked="true" name="ATH">
              <check checked="true" name="ATH-cmp-float"/>
              <check checked="true" name="ATH-cmp-unsign-neg"/>
              <check checked="true" name="ATH-cmp-unsign-pos"/>
              <check checked="true" name="ATH-div-0-assign"/>
              <check checked="true" name="ATH-div-0-cmp-aft"/>
              <check checked="true" name="ATH-div-0-cmp-bef"/>
              <check checked="true" name="ATH-div-0-interval"/>
              <check checked="true" name="ATH-div-0-pos"/>
              <check checked="true" name="ATH-div-0-unchk-global"/>
              <check checked="true" name="ATH-div-0-unchk-local"/>
              <check checked="true" name="ATH-div-0-unchk-param"/>
              <check checked="true" name="ATH-div-0"/>
              <check checked="true" name="ATH-inc-bool"/>
              <check checked="true" name="ATH-malloc-overrun"/>
              <check checked="true" name="ATH-neg-check-nonneg"/>
              <check checked="true" name="ATH-neg-check-pos"/>
              <check checked="true" name="ATH-new-overrun"/>
              <check checked="false" name="ATH-overflow-cast"/>
              <check checked="true" name="ATH-overflow"/>
              <check checked="true" name="ATH-shift-bounds"/>
              <check checked="true" name="ATH-shift-neg"/>
              <check checked="true" name="ATH-sizeof-by-sizeof"/>
            </group>
            <group checked="true" name="CAST">
              <check checked="false" name="CAST-old-style"/>
            </group>
            <group checked="true" name="CATCH">
              <check checked="true" name="CATCH-object-slicing"/>
              <check checked="false" name="CATCH-xtor-bad-member"/>
            </group>
            <group checked="true" name="COMMA">
              <check checked="false" name="COMMA-overload"/>
            </group>
            <group checked="true" name="COMMENT">
              <check checked="true" name="COMMENT-nested"/>
            </group>
            <group checked="false" name="CONCURRENCY">
              <check checked="true" name="CONCURRENCY-double-lock"/>
              <check checked="true" name="CONCURRENCY-double-unlock"/>
              <check checked="true" name="CONCURRENCY-lock-no-unlock"/>
              <check checked="true" name="CONCURRENCY-sleep-while-locking"/>
            </group>
            <group checked="true" name="CONST">
              <check checked="false" name="CONST-local"/>
              <check checked="true" name="CONST-member-ret"/>
              <check checked="false" name="CONST-param"/>
            </group>
            <group checked="true" name="COP">
              <check checked="true" name="COP-alloc-ctor"/>
              <check checked="true" name="COP-assign-op-ret"/>
              <check checked="true" name="COP-assign-op-self"/>
              <check checked="true" name="COP-assign-op"/>
              <check checked="true" name="COP-copy-ctor"/>
              <check checked="true" name="COP-dealloc-dtor"/>
              <check checked="true" name="COP-dtor-throw"/>
              <check checked="true" name="COP-dtor"/>
              <check checked="true" name="COP-init-order"/>
              <check checked="true" name="COP-init-uninit"/>
              <check checked="true" name="COP-member-uninit"/>
            </group>
            <group checked="true" name="CPU">
              <check checked="true" name="CPU-ctor-call-virt"/>
              <check checked="false" name="CPU-ctor-implicit"/>
              <check checked="true" name="CPU-delete-throw"/>
              <check checked="true" name="CPU-delete-void"/>
              <check checked="true" name="CPU-dtor-call-virt"/>
              <check checked="true" name="CPU-malloc-class"/>
              <check checked="true" name="CPU-nonvirt-dtor"/>
              <check checked="true" name="CPU-return-ref-to-class-data"/>
            </group>
            <group checked="true" name="DECL">
              <check checked="false" name="DECL-implicit-int"/>
            </group>
            <group checked="true" name="DEFINE">
              <check checked="true" name="DEFINE-hash-multiple"/>
            </group>
            <group checked="true" name="ENUM">
              <check checked="false" name="ENUM-bounds"/>
            </group>
            <group checked="true" name="EXP">
              <check checked="true" name="EXP-cond-assign"/>
              <check checked="true" name="EXP-dangling-else"/>
              <check checked="true" name="EXP-loop-exit"/>
              <check checked="false" name="EXP-main-ret-int"/>
              <check checked="false" name="EXP-null-stmt"/>
              <check checked="false" name="EXP-stray-semicolon"/>
            </group>
            <group checked="true" name="EXPR">
              <check checked="true" name="EXPR-const-overflow"/>
            </group>
            <group checked="false" name="FPT">
              <check checked="true" name="FPT-arith-address"/>
              <check checked="true" name="FPT-arith"/>
              <check checked="true" name="FPT-cmp-null"/>
              <check checked="false" name="FPT-literal"/>
              <check checked="true" name="FPT-misuse"/>
            </group>
            <group checked="true" name="FUNC">
              <check checked="false" name="FUNC-implicit-decl"/>
              <check checked="false" name="FUNC-unprototyped-all"/>
              <check checked="true" name="FUNC-unprototyped-used"/>
            </group>
            <group checked="true" name="INCLUDE">
              <check checked="false" name="INCLUDE-c-file"/>
            </group>
            <group checked="true" name="INT">
              <check checked="false" name="INT-use-signed-as-unsigned-pos"/>
              <check checked="true" name="INT-use-signed-as-unsigned"/>
            </group>
            <group checked="true" name="ITR">
              <check checked="true" name="ITR-end-cmp-aft"/>
              <check checked="true" name="ITR-end-cmp-bef"/>
              <check checked="true" name="ITR-invalidated"/>
              <check checked="true" name="ITR-mismatch-alg"/>
              <check checked="true" name="ITR-store"/>
              <check checked="true" name="ITR-uninit"/>
            </group>
            <group checked="true" name="LIB">
              <check checked="false" name="LIB-bsearch-overrun-pos"/>
              <check checked="false" name="LIB-bsearch-overrun"/>
              <check checked="false" name="LIB-buf-size"/>
              <check checked="false" name="LIB-fn-unsafe"/>
              <check checked="false" name="LIB-fread-overrun-pos"/>
              <check checked="true" name="LIB-fread-overrun"/>
              <check checked="false" name="LIB-memchr-overrun-pos"/>
              <check checked="true" name="LIB-memchr-overrun"/>
              <check checked="false" name="LIB-memcpy-overrun-pos"/>
              <check checked="true" name="LIB-memcpy-overrun"/>
              <check checked="false" name="LIB-memset-overrun-pos"/>
              <check checked="true" name="LIB-memset-overrun"/>
              <check checked="false" name="LIB-putenv"/>
              <check checked="false" name="LIB-qsort-overrun-pos"/>
              <check checked="false" name="LIB-qsort-overrun"/>
              <check checked="true" name="LIB-return-const"/>
              <check checked="true" name="LIB-return-error"/>
              <check checked="true" name="LIB-return-leak"/>
              <check checked="true" name="LIB-return-neg"/>
              <check checked="true" name="LIB-return-null"/>
              <check checked="false" name="LIB-sprintf-overrun"/>
              <check checked="false" name="LIB-std-sort-overrun-pos"/>
              <check checked="true" name="LIB-std-sort-overrun"/>
              <check checked="false" name="LIB-strcat-overrun-pos"/>
              <check checked="true" name="LIB-strcat-overrun"/>
              <check checked="false" name="LIB-strcpy-overrun-pos"/>
              <check checked="true" name="LIB-strcpy-overrun"/>
              <check checked="false" name="LIB-strncat-overrun-pos"/>
              <check checked="true" name="LIB-strncat-overrun"/>
              <check checked="false" name="LIB-strncmp-overrun-pos"/>
              <check checked="true" name="LIB-strncmp-overrun"/>
              <check checked="false" name="LIB-strncpy-overrun-pos"/>
              <check checked="true" name="LIB-strncpy-overrun"/>
            </group>
            <group checked="true" name="LOGIC">
              <check checked="false" name="LOGIC-overload"/>
            </group>
            <group checked="false" name="MEM">
              <check checked="true" name="MEM-alias-double-free"/>
              <check checked="true" name="MEM-delete-array-op"/>
              <check checked="true" name="MEM-delete-op"/>
              <check checked="true" name="MEM-double-free-alias"/>
              <check checked="true" name="MEM-double-free-some"/>
              <check checked="true" name="MEM-double-free"/>
              <check checked="true" name="MEM-free-field"/>
              <check checked="true" name="MEM-free-fptr"/>
              <check checked="false" name="MEM-free-no-alloc-struct"/>
              <check checked="true" name="MEM-free-no-alloc"/>
              <check checked="true" name="MEM-free-no-use"/>
              <check checked="true" name="MEM-free-op"/>
              <check checked="true" name="MEM-free-struct-field"/>
              <check checked="true" name="MEM-free-variable-alias"/>
              <check checked="true" name="MEM-free-variable"/>
              <check checked="true" name="MEM-leak-alias"/>
              <check checked="false" name="MEM-leak"/>
              <check checked="false" name="MEM-malloc-arith"/>
              <check checked="true" name="MEM-malloc-diff-type"/>
              <check checked="true" name="MEM-malloc-sizeof-ptr"/>
              <check checked="true" name="MEM-malloc-sizeof"/>
              <check checked="false" name="MEM-malloc-strlen"/>
              <check checked="true" name="MEM-realloc-diff-type"/>
              <check checked="true" name="MEM-return-free"/>
              <check checked="true" name="MEM-return-no-assign"/>
              <check checked="true" name="MEM-stack-alias"/>
              <check checked="true" name="MEM-stack-global-alias"/>
              <check checked="true" name="MEM-stack-global-field"/>
              <check checked="true" name="MEM-stack-global"/>
              <check checked="true" name="MEM-stack-param-ref"/>
              <check checked="true" name="MEM-stack-param"/>
              <check checked="true" name="MEM-stack-pos"/>
              <check checked="true" name="MEM-stack-ref"/>
              <check checked="true" name="MEM-stack"/>
              <check checked="true" name="MEM-use-free-all"/>
              <check checked="true" name="MEM-use-free-some"/>
            </group>
            <group checked="false" name="POR">
              <check checked="true" name="POR-imp-cast-subscript"/>
              <check checked="false" name="POR-imp-cast-ternary"/>
            </group>
            <group checked="true" name="PTR">
              <check checked="true" name="PTR-arith-field"/>
              <check checked="true" name="PTR-arith-stack"/>
              <check checked="true" name="PTR-arith-var"/>
              <check checked="true" name="PTR-cmp-str-lit"/>
              <check checked="true" name="PTR-null-assign-fun-pos"/>
              <check checked="true" name="PTR-null-assign-pos"/>
              <check checked="true" name="PTR-null-assign"/>
              <check checked="true" name="PTR-null-cmp-aft"/>
              <check checked="true" name="PTR-null-cmp-bef-fun"/>
              <check checked="true" name="PTR-null-cmp-bef"/>
              <check checked="true" name="PTR-null-fun-pos"/>
              <check checked="true" name="PTR-null-literal-pos"/>
              <check checked="false" name="PTR-overload"/>
              <check checked="true" name="PTR-singleton-arith-pos"/>
              <check checked="true" name="PTR-singleton-arith"/>
              <check checked="true" name="PTR-unchk-param-some"/>
              <check checked="false" name="PTR-unchk-param"/>
              <check checked="true" name="PTR-uninit-pos"/>
              <check checked="true" name="PTR-uninit"/>
            </group>
            <group checked="true" name="RED">
              <check checked="false" name="RED-case-reach"/>
              <check checked="false" name="RED-cmp-always"/>
              <check checked="false" name="RED-cmp-never"/>
              <check checked="false" name="RED-cond-always"/>
              <check checked="true" name="RED-cond-const-assign"/>
              <check checked="false" name="RED-cond-const-expr"/>
              <check checked="false" name="RED-cond-const"/>
              <check checked="false" name="RED-cond-never"/>
              <check checked="true" name="RED-dead"/>
              <check checked="false" name="RED-expr"/>
              <check checked="false" name="RED-func-no-effect"/>
              <check checked="true" name="RED-local-hides-global"/>
              <check checked="true" name="RED-local-hides-local"/>
              <check checked="true" name="RED-local-hides-member"/>
              <check checked="true" name="RED-local-hides-param"/>
              <check checked="false" name="RED-no-effect"/>
              <check checked="true" name="RED-self-assign"/>
              <check checked="true" name="RED-unused-assign"/>
              <check checked="false" name="RED-unused-param"/>
              <check checked="false" name="RED-unused-return-val"/>
              <check checked="false" name="RED-unused-val"/>
              <check checked="true" name="RED-unused-var-all"/>
            </group>
            <group checked="true" name="RESOURCE">
              <check checked="false" name="RESOURCE-deref-file"/>
              <check checked="true" name="RESOURCE-double-close"/>
              <check checked="true" name="RESOURCE-file-no-close-all"/>
              <check checked="false" name="RESOURCE-file-pos-neg"/>
              <check checked="true" name="RESOURCE-file-use-after-close"/>
              <check checked="false" name="RESOURCE-implicit-deref-file"/>
              <check checked="true" name="RESOURCE-write-ronly-file"/>
            </group>
            <group checked="false" name="SEM">
              <check checked="false" name="SEM-const-call"/>
              <check checked="false" name="SEM-const-global"/>
              <check checked="false" name="SEM-pure-call"/>
              <check checked="false" name="SEM-pure-global"/>
            </group>
            <group checked="true" name="SIZEOF">
              <check checked="true" name="SIZEOF-side-effect"/>
            </group>
            <group checked="true" name="SPC">
              <check checked="false" name="SPC-init-list"/>
              <check checked="true" name="SPC-order"/>
              <check checked="true" name="SPC-return"/>
              <check checked="true" name="SPC-uninit-arr-all"/>
              <check checked="true" name="SPC-uninit-struct-field-heap"/>
              <check checked="true" name="SPC-uninit-struct-field"/>
              <check checked="true" name="SPC-uninit-struct"/>
              <check checked="true" name="SPC-uninit-var-all"/>
              <check checked="true" name="SPC-uninit-var-some"/>
              <check checked="false" name="SPC-volatile-reads"/>
              <check checked="false" name="SPC-volatile-writes"/>
            </group>
            <group checked="true" name="STR">
              <check checked="true" name="STR-trigraph"/>
            </group>
            <group checked="true" name="STRUCT">
              <check checked="false" name="STRUCT-signed-bit"/>
            </group>
            <group checked="true" name="SWITCH">
              <check checked="true" name="SWITCH-fall-through"/>
            </group>
            <group checked="true" name="THROW">
              <check checked="false" name="THROW-empty"/>
              <check checked="false" name="THROW-main"/>
              <check checked="true" name="THROW-null"/>
              <check checked="true" name="THROW-ptr"/>
              <check checked="true" name="THROW-static"/>
              <check checked="true" name="THROW-unhandled"/>
            </group>
            <group checked="true" name="UNION">
              <check checked="true" name="UNION-overlap-assign"/>
              <check checked="true" name="UNION-type-punning"/>
            </group>
          </package>
          <package checked="false" name="MISRAC2004">
            <group checked="false" name="MISRAC2004-1">
              <check checked="true" name="MISRAC2004-1.1"/>
              <check checked="true" name="MISRAC2004-1.2_a"/>
              <check checked="true" name="MISRAC2004-1.2_b"/>
              <check checked="true" name="MISRAC2004-1.2_c"/>
              <check checked="true" name="MISRAC2004-1.2_d"/>
              <check checked="true" name="MISRAC2004-1.2_e"/>
              <check checked="true" name="MISRAC2004-1.2_f"/>
              <check checked="true" name="MISRAC2004-1.2_g"/>
              <check checked="true" name="MISRAC2004-1.2_h"/>
              <check checked="true" name="MISRAC2004-1.2_i"/>
              <check checked="true" name="MISRAC2004-1.2_j"/>
            </group>
            <group checked="true" name="MISRAC2004-2">
              <check checked="true" name="MISRAC2004-2.1"/>
              <check checked="true" name="MISRAC2004-2.2"/>
              <check checked="true" name="MISRAC2004-2.3"/>
              <check checked="false" name="MISRAC2004-2.4"/>
            </group>
            <group checked="true" name="MISRAC2004-4">
              <check checked="true" name="MISRAC2004-4.2"/>
            </group>
            <group checked="true" name="MISRAC2004-5">
              <check checked="true" name="MISRAC2004-5.2_a"/>
              <check checked="true" name="MISRAC2004-5.2_b"/>
              <check checked="true" name="MISRAC2004-5.2_c"/>
              <check checked="true" name="MISRAC2004-5.3"/>
              <check checked="true" name="MISRAC2004-5.4"/>
              <check checked="false" name="MISRAC2004-5.5"/>
            </group>
            <group checked="true" name="MISRAC2004-6">
              <check checked="true" name="MISRAC2004-6.1"/>
              <check checked="false" name="MISRAC2004-6.3"/>
              <check checked="true" name="MISRAC2004-6.4"/>
              <check checked="true" name="MISRAC2004-6.5"/>
            </group>
            <group checked="true" name="MISRAC2004-7">
              <check checked="true" name="MISRAC2004-7.1"/>
            </group>
            <group checked="true" name="MISRAC2004-8">
              <check checked="true" name="MISRAC2004-8.1"/>
              <check checked="true" name="MISRAC2004-8.2"/>
              <check checked="true" name="MISRAC2004-8.5_a"/>
              <check checked="true" name="MISRAC2004-8.5_b"/>
              <check checked="true" name="MISRAC2004-8.12"/>
            </group>
            <group checked="true" name="MISRAC2004-9">
              <check checked="true" name="MISRAC2004-9.1_a"/>
              <check checked="true" name="MISRAC2004-9.1_b"/>
              <check checked="true" name="MISRAC2004-9.1_c"/>
              <check checked="true" name="MISRAC2004-9.2"/>
            </group>
            <group checked="true" name="MISRAC2004-10">
              <check checked="true" name="MISRAC2004-10.1_a"/>
              <check checked="true" name="MISRAC2004-10.1_b"/>
              <check checked="true" name="MISRAC2004-10.1_c"/>
              <check checked="true" name="MISRAC2004-10.1_d"/>
              <check checked="true" name="MISRAC2004-10.2_a"/>
              <check checked="true" name="MISRAC2004-10.2_b"/>
              <check checked="true" name="MISRAC2004-10.2_c"/>
              <check checked="true" name="MISRAC2004-10.2_d"/>
              <check checked="true" name="MISRAC2004-10.3"/>
              <check checked="true" name="MISRAC2004-10.4"/>
              <check checked="true" name="MISRAC2004-10.5"/>
              <check checked="true" name="MISRAC2004-10.6"/>
            </group>
            <group checked="true" name="MISRAC2004-11">
              <check checked="true" name="MISRAC2004-11.1"/>
              <check checked="false" name="MISRAC2004-11.3"/>
              <check checked="false" name="MISRAC2004-11.4"/>
              <check checked="true" name="MISRAC2004-11.5"/>
            </group>
            <group checked="true" name="MISRAC2004-12">
              <check checked="false" name="MISRAC2004-12.1"/>
              <check checked="true" name="MISRAC2004-12.2_a"/>
              <check checked="true" name="MISRAC2004-12.2_b"/>
              <check checked="true" name="MISRAC2004-12.2_c"/>
              <check checked="true" name="MISRAC2004-12.3"/>
              <check checked="true" name="MISRAC2004-12.4"/>
              <check checked="false" name="MISRAC2004-12.6_a"/>
              <check checked="false" name="MISRAC2004-12.6_b"/>
              <check checked="true" name="MISRAC2004-12.7"/>
              <check checked="true" name="MISRAC2004-12.8"/>
              <check checked="true" name="MISRAC2004-12.9"/>
              <check checked="true" name="MISRAC2004-12.10"/>
              <check checked="false" name="MISRAC2004-12.11"/>
              <check checked="true" name="MISRAC2004-12.12_a"/>
              <check checked="true" name="MISRAC2004-12.12_b"/>
              <check checked="false" name="MISRAC2004-12.13"/>
            </group>
            <group checked="true" name="MISRAC2004-13">
              <check checked="true" name="MISRAC2004-13.1"/>
              <check checked="false" name="MISRAC2004-13.2_a"/>
              <check checked="false" name="MISRAC2004-13.2_b"/>
              <check checked="false" name="MISRAC2004-13.2_c"/>
              <check checked="false" name="MISRAC2004-13.2_d"/>
              <check checked="false" name="MISRAC2004-13.2_e"/>
              <check checked="true" name="MISRAC2004-13.3"/>
              <check checked="true" name="MISRAC2004-13.4"/>
              <check checked="true" name="MISRAC2004-13.5"/>
              <check checked="true" name="MISRAC2004-13.6"/>
              <check checked="true" name="MISRAC2004-13.7_a"/>
              <check checked="true" name="MISRAC2004-13.7_b"/>
            </group>
            <group checked="true" name="MISRAC2004-14">
              <check checked="true" name="MISRAC2004-14.1"/>
              <check checked="true" name="MISRAC2004-14.2"/>
              <check checked="true" name="MISRAC2004-14.3"/>
              <check checked="true" name="MISRAC2004-14.4"/>
              <check checked="true" name="MISRAC2004-14.5"/>
              <check checked="true" name="MISRAC2004-14.6"/>
              <check checked="true" name="MISRAC2004-14.7"/>
              <check checked="true" name="MISRAC2004-14.8_a"/>
              <check checked="true" name="MISRAC2004-14.8_b"/>
              <check checked="true" name="MISRAC2004-14.8_c"/>
              <check checked="true" name="MISRAC2004-14.8_d"/>
              <check checked="true" name="MISRAC2004-14.9"/>
              <check checked="true" name="MISRAC2004-14.10"/>
            </group>
            <group checked="true" name="MISRAC2004-15">
              <check checked="true" name="MISRAC2004-15.0"/>
              <check checked="true" name="MISRAC2004-15.1"/>
              <check checked="true" name="MISRAC2004-15.2"/>
              <check checked="true" name="MISRAC2004-15.3"/>
              <check checked="true" name="MISRAC2004-15.4"/>
              <check checked="true" name="MISRAC2004-15.5"/>
            </group>
            <group checked="true" name="MISRAC2004-16">
              <check checked="true" name="MISRAC2004-16.1"/>
              <check checked="true" name="MISRAC2004-16.2_a"/>
              <check checked="true" name="MISRAC2004-16.2_b"/>
              <check checked="true" name="MISRAC2004-16.3"/>
              <check checked="true" name="MISRAC2004-16.5"/>
              <check checked="true" name="MISRAC2004-16.7"/>
              <check checked="true" name="MISRAC2004-16.8"/>
              <check checked="true" name="MISRAC2004-16.9"/>
              <check checked="true" name="MISRAC2004-16.10"/>
            </group>
            <group checked="true" name="MISRAC2004-17">
              <check checked="true" name="MISRAC2004-17.1_a"/>
              <check checked="true" name="MISRAC2004-17.1_b"/>
              <check checked="true" name="MISRAC2004-17.1_c"/>
              <check checked="true" name="MISRAC2004-17.4_a"/>
              <check checked="true" name="MISRAC2004-17.4_b"/>
              <check checked="true" name="MISRAC2004-17.5"/>
              <check checked="true" name="MISRAC2004-17.6_a"/>
              <check checked="true" name="MISRAC2004-17.6_b"/>
              <check checked="true" name="MISRAC2004-17.6_c"/>
              <check checked="true" name="MISRAC2004-17.6_d"/>
            </group>
            <group checked="true" name="MISRAC2004-18">
              <check checked="true" name="MISRAC2004-18.1"/>
              <check checked="true" name="MISRAC2004-18.2"/>
              <check checked="true" name="MISRAC2004-18.4"/>
            </group>
            <group checked="true" name="MISRAC2004-19">
              <check checked="false" name="MISRAC2004-19.2"/>
              <check checked="true" name="MISRAC2004-19.6"/>
              <check checked="false" name="MISRAC2004-19.7"/>
              <check checked="true" name="MISRAC2004-19.12"/>
              <check checked="false" name="MISRAC2004-19.13"/>
              <check checked="true" name="MISRAC2004-19.15"/>
            </group>
            <group checked="true" name="MISRAC2004-20">
              <check checked="true" name="MISRAC2004-20.1"/>
              <check checked="true" name="MISRAC2004-20.4"/>
              <check checked="true" name="MISRAC2004-20.5"/>
              <check checked="true" name="MISRAC2004-20.6"/>
              <check checked="true" name="MISRAC2004-20.7"/>
              <check checked="true" name="MISRAC2004-20.8"/>
              <check checked="true" name="MISRAC2004-20.9"/>
              <check checked="true" name="MISRAC2004-20.10"/>
              <check checked="true" name="MISRAC2004-20.11"/>
              <check checked="true" name="MISRAC2004-20.12"/>
            </group>
          </package>
          <package checked="false" name="MISRAC2012">
            <group checked="true" name="MISRAC2012-Dir-4">
              <check checked="true" name="MISRAC2012-Dir-4.3"/>
              <check checked="false" name="MISRAC2012-Dir-4.4"/>
              <check checked="false" name="MISRAC2012-Dir-4.6_a"/>
              <check checked="false" name="MISRAC2012-Dir-4.6_b"/>
              <check checked="false" name="MISRAC2012-Dir-4.9"/>
              <check checked="true" name="MISRAC2012-Dir-4.10"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-1">
              <check checked="true" name="MISRAC2012-Rule-1.3_a"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_b"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_c"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_d"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_e"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_f"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_g"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_h"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-2">
              <check checked="true" name="MISRAC2012-Rule-2.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-2.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-2.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-2.2_c"/>
              <check checked="false" name="MISRAC2012-Rule-2.7"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-3">
              <check checked="true" name="MISRAC2012-Rule-3.1"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-4">
              <check checked="false" name="MISRAC2012-Rule-4.2"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-5">
              <check checked="true" name="MISRAC2012-Rule-5.1"/>
              <check checked="true" name="MISRAC2012-Rule-5.3_a"/>
              <check checked="true" name="MISRAC2012-Rule-5.3_b"/>
              <check checked="true" name="MISRAC2012-Rule-5.3_c"/>
              <check checked="true" name="MISRAC2012-Rule-5.4_c89"/>
              <check checked="true" name="MISRAC2012-Rule-5.4_c99"/>
              <check checked="true" name="MISRAC2012-Rule-5.5_c89"/>
              <check checked="true" name="MISRAC2012-Rule-5.5_c99"/>
              <check checked="true" name="MISRAC2012-Rule-5.6"/>
              <check checked="true" name="MISRAC2012-Rule-5.7"/>
              <check checked="true" name="MISRAC2012-Rule-5.8"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-6">
              <check checked="true" name="MISRAC2012-Rule-6.1"/>
              <check checked="true" name="MISRAC2012-Rule-6.2"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-7">
              <check checked="true" name="MISRAC2012-Rule-7.1"/>
              <check checked="true" name="MISRAC2012-Rule-7.2"/>
              <check checked="true" name="MISRAC2012-Rule-7.3"/>
              <check checked="true" name="MISRAC2012-Rule-7.4_a"/>
              <check checked="true" name="MISRAC2012-Rule-7.4_b"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-8">
              <check checked="true" name="MISRAC2012-Rule-8.1"/>
              <check checked="true" name="MISRAC2012-Rule-8.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-8.2_b"/>
              <check checked="true" name="MISRAC2012-Rule-8.10"/>
              <check checked="false" name="MISRAC2012-Rule-8.11"/>
              <check checked="true" name="MISRAC2012-Rule-8.14"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-9">
              <check checked="true" name="MISRAC2012-Rule-9.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_c"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_d"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_e"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_f"/>
              <check checked="true" name="MISRAC2012-Rule-9.3"/>
              <check checked="true" name="MISRAC2012-Rule-9.5_a"/>
              <check checked="true" name="MISRAC2012-Rule-9.5_b"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-10">
              <check checked="true" name="MISRAC2012-Rule-10.1_R2"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R3"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R4"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R5"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R6"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R7"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R8"/>
              <check checked="true" name="MISRAC2012-Rule-10.2"/>
              <check checked="true" name="MISRAC2012-Rule-10.3"/>
              <check checked="true" name="MISRAC2012-Rule-10.4"/>
              <check checked="true" name="MISRAC2012-Rule-10.6"/>
              <check checked="true" name="MISRAC2012-Rule-10.7"/>
              <check checked="true" name="MISRAC2012-Rule-10.8"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-11">
              <check checked="true" name="MISRAC2012-Rule-11.1"/>
              <check checked="true" name="MISRAC2012-Rule-11.3"/>
              <check checked="false" name="MISRAC2012-Rule-11.4"/>
              <check checked="true" name="MISRAC2012-Rule-11.7"/>
              <check checked="true" name="MISRAC2012-Rule-11.8"/>
              <check checked="true" name="MISRAC2012-Rule-11.9"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-12">
              <check checked="false" name="MISRAC2012-Rule-12.1"/>
              <check checked="true" name="MISRAC2012-Rule-12.2"/>
              <check checked="false" name="MISRAC2012-Rule-12.3"/>
              <check checked="false" name="MISRAC2012-Rule-12.4"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-13">
              <check checked="true" name="MISRAC2012-Rule-13.1"/>
              <check checked="true" name="MISRAC2012-Rule-13.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-13.2_b"/>
              <check checked="true" name="MISRAC2012-Rule-13.2_c"/>
              <check checked="false" name="MISRAC2012-Rule-13.3"/>
              <check checked="false" name="MISRAC2012-Rule-13.4_a"/>
              <check checked="false" name="MISRAC2012-Rule-13.4_b"/>
              <check checked="true" name="MISRAC2012-Rule-13.5"/>
              <check checked="true" name="MISRAC2012-Rule-13.6"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-14">
              <check checked="true" name="MISRAC2012-Rule-14.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-14.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-14.2"/>
              <check checked="true" name="MISRAC2012-Rule-14.3_a"/>
              <check checked="true" name="MISRAC2012-Rule-14.3_b"/>
              <check checked="true" name="MISRAC2012-Rule-14.4_a"/>
              <check checked="true" name="MISRAC2012-Rule-14.4_b"/>
              <check checked="true" name="MISRAC2012-Rule-14.4_c"/>
              <check checked="true" name="MISRAC2012-Rule-14.4_d"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-15">
              <check checked="false" name="MISRAC2012-Rule-15.1"/>
              <check checked="true" name="MISRAC2012-Rule-15.2"/>
              <check checked="true" name="MISRAC2012-Rule-15.3"/>
              <check checked="false" name="MISRAC2012-Rule-15.4"/>
              <check checked="false" name="MISRAC2012-Rule-15.5"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_a"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_b"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_c"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_d"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_e"/>
              <check checked="true" name="MISRAC2012-Rule-15.7"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-16">
              <check checked="true" name="MISRAC2012-Rule-16.1"/>
              <check checked="true" name="MISRAC2012-Rule-16.2"/>
              <check checked="true" name="MISRAC2012-Rule-16.3"/>
              <check checked="true" name="MISRAC2012-Rule-16.4"/>
              <check checked="true" name="MISRAC2012-Rule-16.5"/>
              <check checked="true" name="MISRAC2012-Rule-16.6"/>
              <check checked="true" name="MISRAC2012-Rule-16.7"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-17">
              <check checked="true" name="MISRAC2012-Rule-17.1"/>
              <check checked="true" name="MISRAC2012-Rule-17.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-17.2_b"/>
              <check checked="true" name="MISRAC2012-Rule-17.3"/>
              <check checked="true" name="MISRAC2012-Rule-17.4"/>
              <check checked="true" name="MISRAC2012-Rule-17.6"/>
              <check checked="true" name="MISRAC2012-Rule-17.7"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-18">
              <check checked="true" name="MISRAC2012-Rule-18.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-18.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-18.1_c"/>
              <check checked="true" name="MISRAC2012-Rule-18.1_d"/>
              <check checked="false" name="MISRAC2012-Rule-18.5"/>
              <check checked="true" name="MISRAC2012-Rule-18.6_a"/>
              <check checked="true" name="MISRAC2012-Rule-18.6_b"/>
              <check checked="true" name="MISRAC2012-Rule-18.6_c"/>
              <check checked="true" name="MISRAC2012-Rule-18.6_d"/>
              <check checked="true" name="MISRAC2012-Rule-18.7"/>
              <check checked="true" name="MISRAC2012-Rule-18.8"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-19">
              <check checked="true" name="MISRAC2012-Rule-19.1"/>
              <check checked="false" name="MISRAC2012-Rule-19.2"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-20">
              <check checked="true" name="MISRAC2012-Rule-20.2"/>
              <check checked="true" name="MISRAC2012-Rule-20.4_c89"/>
              <check checked="true" name="MISRAC2012-Rule-20.4_c99"/>
              <check checked="false" name="MISRAC2012-Rule-20.5"/>
              <check checked="false" name="MISRAC2012-Rule-20.10"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-21">
              <check checked="true" name="MISRAC2012-Rule-21.1"/>
              <check checked="true" name="MISRAC2012-Rule-21.2"/>
              <check checked="true" name="MISRAC2012-Rule-21.3"/>
              <check checked="true" name="MISRAC2012-Rule-21.4"/>
              <check checked="true" name="MISRAC2012-Rule-21.5"/>
              <check checked="true" name="MISRAC2012-Rule-21.6"/>
              <check checked="true" name="MISRAC2012-Rule-21.7"/>
              <check checked="true" name="MISRAC2012-Rule-21.8"/>
              <check checked="true" name="MISRAC2012-Rule-21.9"/>
              <check checked="true" name="MISRAC2012-Rule-21.10"/>
              <check checked="true" name="MISRAC2012-Rule-21.11"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-22">
              <check checked="true" name="MISRAC2012-Rule-22.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-22.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-22.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-22.2_b"/>
              <check checked="true" name="MISRAC2012-Rule-22.2_c"/>
              <check checked="true" name="MISRAC2012-Rule-22.4"/>
              <check checked="true" name="MISRAC2012-Rule-22.5_a"/>
              <check checked="true" name="MISRAC2012-Rule-22.5_b"/>
              <check checked="true" name="MISRAC2012-Rule-22.6"/>
            </group>
          </package>
          <package checked="false" name="MISRAC++2008">
            <group checked="true" name="MISRAC++2008-0-1">
              <check checked="true" name="MISRAC++2008-0-1-1"/>
              <check checked="true" name="MISRAC++2008-0-1-2_a"/>
              <check checked="true" name="MISRAC++2008-0-1-2_b"/>
              <check checked="true" name="MISRAC++2008-0-1-2_c"/>
              <check checked="true" name="MISRAC++2008-0-1-3"/>
              <check checked="true" name="MISRAC++2008-0-1-4"/>
              <check checked="true" name="MISRAC++2008-0-1-6"/>
              <check checked="true" name="MISRAC++2008-0-1-7"/>
              <check checked="false" name="MISRAC++2008-0-1-8"/>
              <check checked="true" name="MISRAC++2008-0-1-9"/>
              <check checked="true" name="MISRAC++2008-0-1-11"/>
            </group>
            <group checked="true" name="MISRAC++2008-0-2">
              <check checked="true" name="MISRAC++2008-0-2-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-0-3">
              <check checked="true" name="MISRAC++2008-0-3-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-2-3">
              <check checked="true" name="MISRAC++2008-2-3-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-2-7">
              <check checked="true" name="MISRAC++2008-2-7-1"/>
              <check checked="true" name="MISRAC++2008-2-7-2"/>
              <check checked="false" name="MISRAC++2008-2-7-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-2-10">
              <check checked="true" name="MISRAC++2008-2-10-2_a"/>
              <check checked="true" name="MISRAC++2008-2-10-2_b"/>
              <check checked="true" name="MISRAC++2008-2-10-2_c"/>
              <check checked="true" name="MISRAC++2008-2-10-2_d"/>
              <check checked="true" name="MISRAC++2008-2-10-3"/>
              <check checked="true" name="MISRAC++2008-2-10-4"/>
              <check checked="false" name="MISRAC++2008-2-10-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-2-13">
              <check checked="true" name="MISRAC++2008-2-13-2"/>
              <check checked="true" name="MISRAC++2008-2-13-3"/>
              <check checked="true" name="MISRAC++2008-2-13-4_a"/>
              <check checked="true" name="MISRAC++2008-2-13-4_b"/>
            </group>
            <group checked="true" name="MISRAC++2008-3-1">
              <check checked="true" name="MISRAC++2008-3-1-1"/>
              <check checked="true" name="MISRAC++2008-3-1-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-3-9">
              <check checked="false" name="MISRAC++2008-3-9-2"/>
              <check checked="true" name="MISRAC++2008-3-9-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-4-5">
              <check checked="true" name="MISRAC++2008-4-5-1"/>
              <check checked="true" name="MISRAC++2008-4-5-2"/>
              <check checked="true" name="MISRAC++2008-4-5-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-0">
              <check checked="true" name="MISRAC++2008-5-0-1_a"/>
              <check checked="true" name="MISRAC++2008-5-0-1_b"/>
              <check checked="true" name="MISRAC++2008-5-0-1_c"/>
              <check checked="false" name="MISRAC++2008-5-0-2"/>
              <check checked="true" name="MISRAC++2008-5-0-3"/>
              <check checked="true" name="MISRAC++2008-5-0-4"/>
              <check checked="true" name="MISRAC++2008-5-0-5"/>
              <check checked="true" name="MISRAC++2008-5-0-6"/>
              <check checked="true" name="MISRAC++2008-5-0-7"/>
              <check checked="true" name="MISRAC++2008-5-0-8"/>
              <check checked="true" name="MISRAC++2008-5-0-9"/>
              <check checked="true" name="MISRAC++2008-5-0-10"/>
              <check checked="true" name="MISRAC++2008-5-0-13_a"/>
              <check checked="true" name="MISRAC++2008-5-0-13_b"/>
              <check checked="true" name="MISRAC++2008-5-0-13_c"/>
              <check checked="true" name="MISRAC++2008-5-0-13_d"/>
              <check checked="true" name="MISRAC++2008-5-0-14"/>
              <check checked="true" name="MISRAC++2008-5-0-15_a"/>
              <check checked="true" name="MISRAC++2008-5-0-15_b"/>
              <check checked="true" name="MISRAC++2008-5-0-16_a"/>
              <check checked="true" name="MISRAC++2008-5-0-16_b"/>
              <check checked="true" name="MISRAC++2008-5-0-16_c"/>
              <check checked="true" name="MISRAC++2008-5-0-16_d"/>
              <check checked="true" name="MISRAC++2008-5-0-16_e"/>
              <check checked="true" name="MISRAC++2008-5-0-16_f"/>
              <check checked="true" name="MISRAC++2008-5-0-19"/>
              <check checked="true" name="MISRAC++2008-5-0-21"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-2">
              <check checked="true" name="MISRAC++2008-5-2-4"/>
              <check checked="true" name="MISRAC++2008-5-2-5"/>
              <check checked="true" name="MISRAC++2008-5-2-6"/>
              <check checked="true" name="MISRAC++2008-5-2-7"/>
              <check checked="false" name="MISRAC++2008-5-2-9"/>
              <check checked="false" name="MISRAC++2008-5-2-10"/>
              <check checked="true" name="MISRAC++2008-5-2-11_a"/>
              <check checked="true" name="MISRAC++2008-5-2-11_b"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-3">
              <check checked="true" name="MISRAC++2008-5-3-1"/>
              <check checked="true" name="MISRAC++2008-5-3-2_a"/>
              <check checked="true" name="MISRAC++2008-5-3-2_b"/>
              <check checked="true" name="MISRAC++2008-5-3-3"/>
              <check checked="true" name="MISRAC++2008-5-3-4"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-8">
              <check checked="true" name="MISRAC++2008-5-8-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-14">
              <check checked="true" name="MISRAC++2008-5-14-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-18">
              <check checked="true" name="MISRAC++2008-5-18-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-19">
              <check checked="false" name="MISRAC++2008-5-19-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-2">
              <check checked="true" name="MISRAC++2008-6-2-1"/>
              <check checked="true" name="MISRAC++2008-6-2-2"/>
              <check checked="true" name="MISRAC++2008-6-2-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-3">
              <check checked="true" name="MISRAC++2008-6-3-1_a"/>
              <check checked="true" name="MISRAC++2008-6-3-1_b"/>
              <check checked="true" name="MISRAC++2008-6-3-1_c"/>
              <check checked="true" name="MISRAC++2008-6-3-1_d"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-4">
              <check checked="true" name="MISRAC++2008-6-4-1"/>
              <check checked="true" name="MISRAC++2008-6-4-2"/>
              <check checked="true" name="MISRAC++2008-6-4-3"/>
              <check checked="true" name="MISRAC++2008-6-4-4"/>
              <check checked="true" name="MISRAC++2008-6-4-5"/>
              <check checked="true" name="MISRAC++2008-6-4-6"/>
              <check checked="true" name="MISRAC++2008-6-4-7"/>
              <check checked="true" name="MISRAC++2008-6-4-8"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-5">
              <check checked="true" name="MISRAC++2008-6-5-1_a"/>
              <check checked="true" name="MISRAC++2008-6-5-2"/>
              <check checked="true" name="MISRAC++2008-6-5-3"/>
              <check checked="true" name="MISRAC++2008-6-5-4"/>
              <check checked="true" name="MISRAC++2008-6-5-6"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-6">
              <check checked="true" name="MISRAC++2008-6-6-1"/>
              <check checked="true" name="MISRAC++2008-6-6-2"/>
              <check checked="true" name="MISRAC++2008-6-6-4"/>
              <check checked="true" name="MISRAC++2008-6-6-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-7-1">
              <check checked="true" name="MISRAC++2008-7-1-1"/>
              <check checked="true" name="MISRAC++2008-7-1-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-7-2">
              <check checked="true" name="MISRAC++2008-7-2-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-7-4">
              <check checked="true" name="MISRAC++2008-7-4-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-7-5">
              <check checked="true" name="MISRAC++2008-7-5-1_a"/>
              <check checked="true" name="MISRAC++2008-7-5-1_b"/>
              <check checked="true" name="MISRAC++2008-7-5-2_a"/>
              <check checked="true" name="MISRAC++2008-7-5-2_b"/>
              <check checked="true" name="MISRAC++2008-7-5-2_c"/>
              <check checked="true" name="MISRAC++2008-7-5-2_d"/>
              <check checked="false" name="MISRAC++2008-7-5-4_a"/>
              <check checked="false" name="MISRAC++2008-7-5-4_b"/>
            </group>
            <group checked="true" name="MISRAC++2008-8-0">
              <check checked="true" name="MISRAC++2008-8-0-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-8-4">
              <check checked="true" name="MISRAC++2008-8-4-1"/>
              <check checked="true" name="MISRAC++2008-8-4-3"/>
              <check checked="true" name="MISRAC++2008-8-4-4"/>
            </group>
            <group checked="true" name="MISRAC++2008-8-5">
              <check checked="true" name="MISRAC++2008-8-5-1_a"/>
              <check checked="true" name="MISRAC++2008-8-5-1_b"/>
              <check checked="true" name="MISRAC++2008-8-5-1_c"/>
              <check checked="true" name="MISRAC++2008-8-5-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-9-3">
              <check checked="true" name="MISRAC++2008-9-3-1"/>
              <check checked="true" name="MISRAC++2008-9-3-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-9-5">
              <check checked="true" name="MISRAC++2008-9-5-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-9-6">
              <check checked="true" name="MISRAC++2008-9-6-2"/>
              <check checked="true" name="MISRAC++2008-9-6-3"/>
              <check checked="true" name="MISRAC++2008-9-6-4"/>
            </group>
            <group checked="true" name="MISRAC++2008-12-1">
              <check checked="true" name="MISRAC++2008-12-1-1_a"/>
              <check checked="true" name="MISRAC++2008-12-1-1_b"/>
              <check checked="true" name="MISRAC++2008-12-1-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-15-0">
              <check checked="false" name="MISRAC++2008-15-0-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-15-1">
              <check checked="true" name="MISRAC++2008-15-1-2"/>
              <check checked="true" name="MISRAC++2008-15-1-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-15-3">
              <check checked="true" name="MISRAC++2008-15-3-1"/>
              <check checked="false" name="MISRAC++2008-15-3-2"/>
              <check checked="true" name="MISRAC++2008-15-3-3"/>
              <check checked="true" name="MISRAC++2008-15-3-4"/>
              <check checked="true" name="MISRAC++2008-15-3-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-15-5">
              <check checked="true" name="MISRAC++2008-15-5-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-16-0">
              <check checked="true" name="MISRAC++2008-16-0-3"/>
              <check checked="true" name="MISRAC++2008-16-0-4"/>
            </group>
            <group checked="true" name="MISRAC++2008-16-2">
              <check checked="true" name="MISRAC++2008-16-2-2"/>
              <check checked="true" name="MISRAC++2008-16-2-3"/>
              <check checked="true" name="MISRAC++2008-16-2-4"/>
              <check checked="false" name="MISRAC++2008-16-2-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-16-3">
              <check checked="true" name="MISRAC++2008-16-3-1"/>
              <check checked="false" name="MISRAC++2008-16-3-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-17-0">
              <check checked="true" name="MISRAC++2008-17-0-1"/>
              <check checked="true" name="MISRAC++2008-17-0-3"/>
              <check checked="true" name="MISRAC++2008-17-0-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-18-0">
              <check checked="true" name="MISRAC++2008-18-0-1"/>
              <check checked="true" name="MISRAC++2008-18-0-2"/>
              <check checked="true" name="MISRAC++2008-18-0-3"/>
              <check checked="true" name="MISRAC++2008-18-0-4"/>
              <check checked="true" name="MISRAC++2008-18-0-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-18-2">
              <check checked="true" name="MISRAC++2008-18-2-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-18-4">
              <check checked="true" name="MISRAC++2008-18-4-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-18-7">
              <check checked="true" name="MISRAC++2008-18-7-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-19-3">
              <check checked="true" name="MISRAC++2008-19-3-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-27-0">
              <check checked="true" name="MISRAC++2008-27-0-1"/>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\cfunctions.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\cfunctions.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\cppfunctions.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\LocalTcpServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\mico_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\MICOAppDefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\MICOAppEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\MICOBonjour.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\RemoteTcpClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\SppProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\SppProtocol.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\demos\application\wifi_uart\UartRecv.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-3166</name>
      <file>
        <name>$PROJ_DIR$\..\..\board\MK3166\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\board\MK3166\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\board\MK3166\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>CrabVMS</name>
    <group>
      <name>Crab-Lib</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabBaseType.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabDatetime.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabDefaultApi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabErrorMsg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabExecute.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabExtern.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabFifo.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabMath.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabStream.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabString.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Inc\CrabUtility.h</name>
        </file>
      </group>
      <group>
        <name>port</name>
        <file>
          <name>$PROJ_DIR$\..\Core\Port\CrabConfig.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Port\CrabError.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Port\CrabPlatform.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Core\Lib\Crab.Core.Lite.CM4F.a</name>
      </file>
    </group>
    <group>
      <name>GAP</name>
      <file>
        <name>$PROJ_DIR$\..\GAP\Gap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\GAP\Gap.h</name>
      </file>
    </group>
    <group>
      <name>Hardware</name>
      <group>
        <name>eeprom</name>
        <file>
          <name>$PROJ_DIR$\..\Hardware\eeprom\eeprom.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\eeprom\eeprom.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\eeprom\eepromCfg.h</name>
        </file>
      </group>
      <group>
        <name>nRF24</name>
        <file>
          <name>$PROJ_DIR$\..\Hardware\nRF24\nRF24L01.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\nRF24\nRF24L01.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\nRF24\nRF24L01Cfg.h</name>
        </file>
      </group>
      <group>
        <name>spiflash</name>
        <file>
          <name>$PROJ_DIR$\..\Hardware\spi_flash\spiflash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\spi_flash\spiflash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\spi_flash\spiflashCfg.h</name>
        </file>
      </group>
      <group>
        <name>stm32ext</name>
        <file>
          <name>$PROJ_DIR$\..\Hardware\stm32\stm32ext.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\stm32\stm32ext.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\stm32\stm32gpio.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Hardware\Hardware.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Hardware\Hardware.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Hardware\stm32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Hardware\stm32f4xx_it.h</name>
      </file>
    </group>
    <group>
      <name>Net</name>
      <file>
        <name>$PROJ_DIR$\..\Net\CrabNet.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Net\CrabNet.h</name>
      </file>
    </group>
    <group>
      <name>Platform</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabHardware.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabStorage.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabVersionFW.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabVersionFW.ini</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabVMS.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabApplication.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabBoardApi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabClock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabCommand.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabEvent.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabHardware.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabMicoApi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabPortable.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabStaticApi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabStorage.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabSystem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabTask.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\CrabVMS.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Stream</name>
      <file>
        <name>$PROJ_DIR$\..\Platform\CrabStoreStream.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Platform\CrabStoreStream.h</name>
      </file>
    </group>
    <group>
      <name>USB</name>
      <group>
        <name>core</name>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\src\usb_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\src\usb_dcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\src\usb_dcd_int.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Device\src\usbd_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Device\src\usbd_ioreq.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Device\src\usbd_req.c</name>
        </file>
      </group>
      <group>
        <name>gap</name>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usb_bsp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usb_conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usb_types.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usbd_conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usbd_desc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usbd_desc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usbd_gap.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usbd_gap.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Hardware\usb\usbd_hw_init.c</name>
        </file>
      </group>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\inc\usb_bsp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\inc\usb_core.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\inc\usb_dcd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\inc\usb_dcd_int.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\inc\usb_defines.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Driver\inc\usb_regs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Device\inc\usbd_core.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Device\inc\usbd_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Device\inc\usbd_ioreq.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Device\inc\usbd_req.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ST\USB\Device\inc\usbd_usr.h</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\mico_config.h</name>
    </file>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MiCODrivers\MiCODriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\include\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\mico.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\mico_platform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\mico_rtos.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\mico_security.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\mico_socket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\mico_system.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\mico_wlan.h</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>bluetooth</name>
      <group>
        <name>BTE</name>
        <group>
          <name>Components</name>
          <group>
            <name>gki</name>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\gki\common\gki_buffer.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\gki\common\gki_debug.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\gki\mico\gki_mico.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\gki\common\gki_time.c</name>
            </file>
          </group>
          <group>
            <name>hcis</name>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\hcis\hcill_proto.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\hcis\hcilp.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\hcis\hcisu_h4.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\hcis\hciutil.c</name>
            </file>
          </group>
          <group>
            <name>stack</name>
            <group>
              <name>brcm</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\brcm\brcm_ble.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\brcm\brcm_prm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\brcm\brcm_tbfc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\brcm\bte_brcm.c</name>
              </file>
            </group>
            <group>
              <name>btm</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_acl.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble_addr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble_bgconn.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble_gap.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble_privacy.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_cfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_dev.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_devctl.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_inq.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_pm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_sco.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_sec.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_sec_nvram.c</name>
              </file>
            </group>
            <group>
              <name>btu</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btu\btu_hcif.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btu\btu_init.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\btu\btu_task.c</name>
              </file>
            </group>
            <group>
              <name>gap</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gap\gap_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gap\gap_ble.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gap\gap_conn.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gap\gap_utils.c</name>
              </file>
            </group>
            <group>
              <name>gatt</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\att_protocol.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_attr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_auth.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_cl.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_sr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_utils.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\gatt\legattdb\legattdb.c</name>
              </file>
            </group>
            <group>
              <name>hcic</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\hcic\hciblecmds.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\hcic\hcicmds.c</name>
              </file>
            </group>
            <group>
              <name>l2cap</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_ble.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_ble_conn.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_ble_utils.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_csm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_fcr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_link.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_utils.c</name>
              </file>
            </group>
            <group>
              <name>rfcomm</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\port_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\port_rfc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\port_utils.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_l2cap_if.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_mx_fsm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_port_fsm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_port_if.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_ts_frames.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_utils.c</name>
              </file>
            </group>
            <group>
              <name>sdp</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_db.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_discovery.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_server.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_utils.c</name>
              </file>
            </group>
            <group>
              <name>smp</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\p_256_curvepara.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\p_256_ecc_pp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\p_256_multprecision.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_act.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_br_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_cmac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_keys.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_l2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_utils.c</name>
              </file>
            </group>
            <group>
              <name>wbt</name>
              <file>
                <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\stack\wbt\wbt_ext.c</name>
              </file>
            </group>
          </group>
          <group>
            <name>udrv</name>
            <file>
              <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\udrv\mico\userial_mico.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>gki</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\gki\common\gki.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Components\gki\common\gki_common.h</name>
          </file>
        </group>
        <group>
          <name>mico_bt_api</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_ble_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_dev_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_gatt.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_gatt_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_hidd_ble_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_int.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_l2c_le_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_l2c_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_main.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_rfcomm_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_sco_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_sdp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_sdp_wrapper.c</name>
          </file>
        </group>
        <group>
          <name>Projects</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Projects\bte\main\bte_hcisu.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Projects\bte\main\bte_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Projects\bte\main\bte_load.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Projects\bte\main\bte_version.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\Projects\bte\embedded\mico\lib\mico_post_reset.c</name>
          </file>
        </group>
        <group>
          <name>proto_disp</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\proto_disp\hcidisp.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>firmware</name>
        <group>
          <name>43438A1</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\bluetooth\firmware\43438A1\26MHz\bt_firmware_image.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>mico_bt_platform</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_bt_bus.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_bt_hcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_bt_logmsg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_bt_nvram_access.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_upio.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\bluetooth\dual_mode\BTE_dual_mode.Cortex-M4.IAR.release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\bluetooth\low_energy\BTE_low_energy.Cortex-M4.IAR.release.a</name>
      </file>
    </group>
    <group>
      <name>daemons</name>
      <group>
        <name>bt_smart</name>
        <group>
          <name>include</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\include\mico_bt.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\include\mico_bt_peripheral.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\include\mico_bt_smart_attribute.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\include\mico_bt_smart_interface.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\include\mico_bt_smartbridge.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\include\mico_bt_smartbridge_constants.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\include\mico_bt_smartbridge_gatt.h</name>
          </file>
        </group>
        <group>
          <name>internal</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_peripheral_stack_interface.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_peripheral_stack_interface.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smart_attribute.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_att_cache_manager.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_att_cache_manager.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_helper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_helper.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_socket_manager.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_socket_manager.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_stack_interface.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_stack_interface.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\mico_bt_management.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\mico_bt_peripheral.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\mico_bt_smartbridge.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\mico_bt_smartbridge_cfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\mico_bt_smartbridge_cfg_size.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\bt_smart\mico_bt_smartbridge_gatt.c</name>
        </file>
      </group>
      <group>
        <name>homekit_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\homekit_server\Lib_HomeKit_Server.Cortex-M4.IAR.release.a</name>
        </file>
      </group>
      <group>
        <name>http_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\http-strings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\http-strings.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\http_parse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\http_parse.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\httpd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\httpd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\httpd_handle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\httpd_priv.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\httpd_ssi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\httpd_sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\daemons\http_server\httpd_wsgi.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>display</name>
        <group>
          <name>VGM128064</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\display\VGM128064\AsciiLib.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\display\VGM128064\AsciiLib.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\display\VGM128064\oled.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\display\VGM128064\oled.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\display\VGM128064\oledfont.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>keypad</name>
        <group>
          <name>gpio_button</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\keypad\gpio_button\button.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\keypad\gpio_button\button.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>led</name>
        <group>
          <name>P9813</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\rgb_led\P9813\hsb2rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\rgb_led\P9813\hsb2rgb_led.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\rgb_led\P9813\rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\rgb_led\P9813\rgb_led.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCODriverMFiAuth\MiCODriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-EXT</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext_mfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_EXT\motion_sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_EXT\motion_sensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_EXT\temp_hum_sensor.c</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-STmem</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems_def.h</name>
        </file>
      </group>
      <group>
        <name>motor</name>
        <group>
          <name>dc_motor</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\motor\dc_motor\dc_motor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\motor\dc_motor\dc_motor.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>sensor</name>
        <group>
          <name>ADPS9930</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\APDS9930\APDS9930.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\APDS9930\APDS9930.h</name>
          </file>
        </group>
        <group>
          <name>BMA2x2</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMA2x2\bma2x2.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMA2x2\bma2x2.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMA2x2\bma2x2_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMA2x2\bma2x2_user.h</name>
          </file>
        </group>
        <group>
          <name>BME280</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BME280\bme280.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BME280\bme280.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BME280\bme280_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BME280\bme280_user.h</name>
          </file>
        </group>
        <group>
          <name>BMG160</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMG160\bmg160.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMG160\bmg160.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMG160\bmg160_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMG160\bmg160_user.h</name>
          </file>
        </group>
        <group>
          <name>BMM050</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMM050\bmm050.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMM050\bmm050.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMM050\bmm050_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\BMM050\bmm050_user.h</name>
          </file>
        </group>
        <group>
          <name>DHT11</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\DHT11\DHT11.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\DHT11\DHT11.h</name>
          </file>
        </group>
        <group>
          <name>HTS221</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\HTS221\hts221.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\HTS221\hts221.h</name>
          </file>
        </group>
        <group>
          <name>infrared_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\infrared_adc\infrared_reflective.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\infrared_adc\infrared_reflective.h</name>
          </file>
        </group>
        <group>
          <name>light_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\light_adc\light_sensor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\light_adc\light_sensor.h</name>
          </file>
        </group>
        <group>
          <name>LPS25HB</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\LPS25HB\lps25hb.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\LPS25HB\lps25hb.h</name>
          </file>
        </group>
        <group>
          <name>LSM9DS1</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1_acc_gyr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1_mag.c</name>
          </file>
        </group>
        <group>
          <name>UVIS25</name>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\UVIS25\uvis25.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\libraries\drivers\sensor\UVIS25\uvis25.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>protocols</name>
      <group>
        <name>gagent</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\protocols\gagent\gagent_cloud_cm4_debug.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\protocols\gagent\gagent_cloud_cm4_release.a</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\protocols\SNTP\sntp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\protocols\SNTP\sntp.h</name>
      </file>
    </group>
    <group>
      <name>utilities</name>
      <group>
        <name>base64</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\base64\base64.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\base64\base64.h</name>
        </file>
      </group>
      <group>
        <name>json_c</name>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\arraylist.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\bits.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\debug.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_inttypes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_object.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_object_private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_tokener.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\json_util.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\linkhash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\printbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\libraries\utilities\json_c\printbuf.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\AESUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\HTTPUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\LinkListUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\SecurityUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\SHAUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\SocketUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\TimeUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\libraries\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>mico</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\core\MiCO.1062.SDIO.Cortex-M4.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\core\MiCO.1062.SPI.Cortex-M4.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\core\MiCO.1088.SDIO.Cortex-M4.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\core\MiCO.3166.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\core\MiCO.3238.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\core\MiCO.3239.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\core\mico_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\core\rf_driver\wlan_firmware.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>LwIP</name>
        <group>
          <name>mico</name>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\net\LwIP\mico\mico_socket.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>RTOS</name>
      <group>
        <name>FreeRTOS</name>
        <group>
          <name>mico</name>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\mico\mico_rtos.c</name>
          </file>
        </group>
        <group>
          <name>ver7.1.0</name>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\croutine.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\portable\MemMang\heap_3.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\list.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\ostimers.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\portable\IAR\ARM_CM4F\port.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\portable\IAR\ARM_CM4F\portasm.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\queue.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\tasks.c</name>
          </file>
        </group>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\RTOS\mico_rtos_common.c</name>
      </file>
    </group>
    <group>
      <name>security</name>
      <group>
        <name>curve25519</name>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\security\Curve25519\curve25519-donna.c</name>
        </file>
      </group>
      <group>
        <name>SHA</name>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\security\SHAUtils\hkdf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\security\SHAUtils\hmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\security\SHAUtils\sha1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\security\SHAUtils\sha224-256.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\security\SHAUtils\sha384-512.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\security\SHAUtils\usha.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\security\Sodium\Lib_Sodium.IAR.release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\security\SRP_6a\Lib_SRP6a.IAR.release.a</name>
      </file>
    </group>
    <group>
      <name>system</name>
      <group>
        <name>easylink</name>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\easylink\airkiss_discovery\airkiss_discovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\easylink\MFi_WAC\Lib_MFi_WAC.IAR.release.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\easylink\airkiss_discovery\lib_airkiss\libairkiss.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\easylink\system_easylink.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\easylink\system_easylink_delegate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\easylink\system_easylink_wac.c</name>
        </file>
      </group>
      <group>
        <name>mdns</name>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\mdns\mico_mdns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\mdns\mico_mdns.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\MiCO\system\mdns\system_discovery.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\config_server\config_server.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\config_server\config_server_menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\command_console\mico_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\command_console\mico_cli.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\mico_system_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\mico_system_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\mico_system_notification.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\mico_system_para_storage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\mico_system_power_daemon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\mico_system_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\system.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\system_factory_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\system_misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\tftp_ota\tftp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\tftp_ota\tftp_ota.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\tftp_ota\tftp_ota.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MiCO\system\tftp_ota\tftpc.o</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M4</name>
      <file>
        <name>$PROJ_DIR$\..\..\platform\Cortex-M4\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\Cortex-M4\hardfault.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\Cortex-M4\platform_core.c</name>
      </file>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx</name>
      <group>
        <name>EWARM</name>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\EWARM\startup_stm32f411xe_IAR.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\EWARM\startup_stm32f412xg_IAR.s</name>
        </file>
      </group>
      <group>
        <name>Peripherals</name>
        <group>
          <name>Libraries</name>
          <group>
            <name>STM32F4xx_StdPeriph_Driver</name>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash_ramfunc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_qspi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\libraries\system_stm32f4xx.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_mcu_powersave.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_pwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_rng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\peripherals\platform_watchdog.c</name>
        </file>
      </group>
      <group>
        <name>Wi-Fi_Bus_Driver</name>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\wlan_bus_driver\wlan_bus_SDIO.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\wlan_bus_driver\wlan_bus_SPI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\wlan_bus_driver\wlan_platform.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\platform\MCU\STM32F4xx\platform_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\platform\MCU\platform_nsclock.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\platform\MCU\mico_platform_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\platform\MCU\wlan_platform_common.c</name>
    </file>
  </group>
</project>


